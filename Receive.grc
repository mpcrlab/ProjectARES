options:
  parameters:
    generate_options: no_gui
    id: receive_proc
    output_language: python
    run_options: run
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {state: disabled}
- name: audio_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '90000000'
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: '89500000'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: record_thresh
  id: variable
  parameters:
    value: '-75'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: record_thresh
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-100'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '720000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: call0.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(
          gr.sync_block
      ):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name="Embedded Python Block",  # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.is_enabled = False

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if not self.is_enabled:
                  if input_items[0][0] != 0:
                      self.is_enabled = True
                      print("enabled")
                      output_items[0][:] = input_items[0]
                  else:
                      output_items[0][:] = -150

              else:
                  output_items[0][:] = input_items[0]
              return len(output_items[0])
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: bb_gain
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'True'
    if_gain0: if_gain
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_head_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_head_0, '0', audio_sink_0, '0']
- [blocks_head_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [epy_block_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
