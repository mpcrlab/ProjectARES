options:
  parameters:
    generate_options: no_gui
    id: transmit_proc
    output_language: python
    run_options: run
  states: {}

blocks:
- name: FM_freq
  id: variable
  parameters:
    value: '89500000'
  states: {}
- name: audio_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate * 80
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: 'audio_rate '
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate * 2
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: 'audio_rate '
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate * 4
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: response0.wav
    repeat: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: bb_gain
    freq0: FM_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate / audio_rate / 4)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate / audio_rate / 2)
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0_0_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
